# IAR project sded5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9G20 Atmel AT91SAM9G20
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; ..\; ..\at91lib\peripherals\pio\; ..\at91lib\peripherals\usb\; ..\at91lib\boards\at91sam9g20-ek\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: ..\at91lib\boards\at91sam9g20-ek\
  AARM.AExtraOptionsV2: -r
  OBJCOPY.OOCOutputFile: sded5.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\Micro\XELTEK\IAR\xeltek\algo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: _dochapi.h doch_ata.cpp doch_ata.h LCD.cpp LCD.h main.cpp main.h PROG_USB.cpp PROG_USB.h PROGPROC.cpp PROGPROC.h sded5.s sdram.icf SOCKET.cpp SOCKET.h
    ../: algo.icf common.h
  group at91lib/boards/at91sam9g20-ek
    ../at91lib/boards/at91sam9g20-ek/: board.h
  group at91lib/boards/at91sam9g20-ek/at91sam9g20
    ../at91lib/boards/at91sam9g20-ek/at91sam9g20/: AT91SAM9G20.h chip.h
  group at91lib/peripherals/pio
    ../at91lib/peripherals/pio/: pio.cpp pio.h
  group at91lib/peripherals/usb
    ../at91lib/peripherals/usb/: chap_9.cpp D14.h kernel.h reqcode.cpp reqcode.h standard.h USB.h usb_init.cpp usb_init.h
